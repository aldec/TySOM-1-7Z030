COMPATIBLE_MACHINE_tysom-1-7z030 = "tysom-1-7z030"
FILESEXTRAPATHS_prepend := "${THISDIR}/platform-init:"
SRC_URI = "file://ps7_init_gpl.c file://ps7_init_gpl.h"

