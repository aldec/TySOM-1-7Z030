FILESEXTRAPATHS_prepend := "${THISDIR}/files/:"

MACHINE_DEVICETREE := " \
	pl.dtsi \
	skeleton.dtsi \
	zynq-7000.dtsi \
	zynq-tysom-1-7z030.dts \
		"
